Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-12-16T11:45:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Dec 16 11:45:36 2021 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{D26786E3-B28D-4F80-912C-4F873274528B}\ifc * Database version: 5507 * Database creation date: Thu Dec 16 11:45:35 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Dec 16 11:45:35 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Dec 16 11:45:35 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFurnishingElement: 2140 - with armrests Camira textile, Furniture_Office-Chairs_Flokk_HAG_Tion_2140:2140 - with armrests Camira textile:19902
In: Level 1
Type - Material: Black RAL 9005, Plastic, Opaque Black, Camira Oceanic Black, Stainless Steel, Polished
Type - Constraints - ArmrestVisibility: yes; FootringVisibility: no
Type - General - Author: BIMStone; BIMObjectName: Furniture_Office-Chairs_Flokk_HAG_Tion_2140; ManufacturerName: Flokk; ManufacturerURL: https://www.flokk.com/; NBSDescription: Office chairs; NBSReference: 45-35-20/330; ProductInformation: n/a adapted to your height and weight.; Revision: n/a; Uniclass2: Pr_40_50_12_57; Uniclass2015Description: Office chairs; Uniclass2015Reference: Pr_40_50_12_57; Version: 1; VersionDate: 28/11/2021
Type - Identity Data - Collection: HAG; Cost: 0; Designer: n/a; EANNumber: n/a; Manufacturer: Flokk; Model: 2140; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: 2140 - with armrests Camira textile; Weight: n/a
Type - Materials and Finishes - OfficeChairMainMaterial: Camira Oceanic Black; OfficeChairQuaternaryMaterial: Black RAL 9005; OfficeChairQuinaryMaterial: Black RAL 9005; OfficeChairSecondaryMaterial: Black RAL 9005; OfficeChairTertiaryMaterial: Plastic, Opaque Black
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: HAG; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Office-Chairs_Flokk_HAG_Tion_2140; Features: Adjustable seat height and depth, adjustable back height and angle; Finish: n/a; Grade: n/a; Material: Textile, metal, plastic; ModelNumber: n/a; ModelReference: n/a; Name: HAG_Tion_2140; ReplacementCost: n/a; Shape: Sculptured; Size: 600x600x710/860 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.64126 m2; Volume: 0.385829 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Furniture_Office-Chairs_Flokk_HAG_Tion_2140: 2140 - with armrests Camira textile; Family and Type: Furniture_Office-Chairs_Flokk_HAG_Tion_2140: 2140 - with armrests Camira textile; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Office-Chairs_Flokk_HAG_Tion_2140: 2140 - with armrests Camira textile; Type Id: Furniture_Office-Chairs_Flokk_HAG_Tion_2140: 2140 - with armrests Camira textile; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
