Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Drawing Scale: 100.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Selected elements only], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Multi-skin complex geometries: Building element parts], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [IFC Site Location: At Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Single Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: All], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: G:\Delte disker\bimbear\01 - Prosjekt\04 - BIM\Flokk\04-Tut\BIM\06 - Utsendelse\2025.10.30 - Flokk - HÅG Tion\IFC\Flokk - HÅG Tion Mesh - 2340 - 200mm Lift.ifc
Time: 2025-11-05T13:30:40
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD-64 22.0.0 INT FULL Windows version (IFC add-on version: 3006 INT FULL).
Authorization: The authorising person

# IfcSite, Site
RefLatitude: 47, 33, 34, 948800; RefLongitude: 19, 3, 17, 204400; RefElevation: 0 mm

# IfcBuildingStorey, Ground Floor
In: Building
Elevation: 0 mm

# IfcFurnishingElement: Flokk - HÅG Tion Mesh - 2340, FU - 002
In: Ground Floor
Classification: Furniture (ARCHICAD Classification)
Pset_ManufacturerTypeInformation - Manufacturer: Flokk
MANUFACTURING - Product Website: www.graphisoft.com
PRODUCT DESCRIPTION (Expression) - Product location: Name of project: Site: Story: Ground Floor Room:; Dynamic ID by Classification: Furniture - 002
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
