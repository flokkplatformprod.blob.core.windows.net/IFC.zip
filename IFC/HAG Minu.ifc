Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: HAG Minu.ifc
Time: 2026-02-02T08:26:15
Written by: pCon.planner

# IfcBuilding
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey
Elevation: 0 m
